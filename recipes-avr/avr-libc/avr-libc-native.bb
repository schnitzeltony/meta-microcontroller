inherit native

require ${BPN}.inc

INSANE_SKIP += "native-last"
